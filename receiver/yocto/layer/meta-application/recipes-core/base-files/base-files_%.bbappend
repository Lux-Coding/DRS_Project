# Change default fstab to mount /boot partition

FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"