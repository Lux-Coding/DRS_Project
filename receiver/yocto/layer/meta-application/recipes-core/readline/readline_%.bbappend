# Change default /etc/inputrc to ubuntu 17.0 inputrc to work nice with putty ssh keycodes e.g. strg + arrow left

FILESEXTRAPATHS_append := "${THISDIR}/files:"